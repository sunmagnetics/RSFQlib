* Circuit for InductEx extraction (excluding resistors)
* Author: L. Schindler
* Version: 2.1
* Last modification date: 27 April 2021
* Last modification by: L. Schindler

.control
	back-annotate LSmitll_MERGET_v2p1_base.cir
.endc

*Inductors
L1 a 1 [L1]
L2 1 4 7p [L2]
L3 4 6 1.1516p [L3]
L4 b 8  [L4]
L5 8 11 7p [L5]
L6 11 13 1.1516p [L6]
L7 7 15 3.432p [L7]
L8 15 17 2.706p [L8]
L9 17 19 2.706p [L9]
L10 19 21  [L10]
LB1 1 3  [LB1]
LB2 8 10  [LB2]
LB3 7 14  [LB3]
LB4 17 18  [LB4]
LP1 2 0  [LP1]
LP2 5 0  [LP2]
LP4 9 0  [LP4]
LP5 12 0 [LP5]
LP7 16 0 [LP7]
LP8 20 0  [LP8]

*Ports
P1 a 0
P2 b 0
P3 21 0
PB1 3 0
PB2 10 0
PB3 14 0
PB4 18 0
J1 1 2 160u
J2 4 5 154u
J3 6 7 95u
J4 8 9 160u
J5 11 12 154u
J6 13 7 95u
J7 15 16 116u
J8 19 20 250u
