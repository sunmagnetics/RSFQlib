* Circuit for InductEx extraction (excluding resistors)
* Author: L. Schindler
* Version: 3.0
* Last modification date: 25 July 2022
* Last modification by: T. Hall
.control
	back-annotate THmitll_SPLIT_v3p0_base.cir
.endc

*Inductors
L1 a 1 2.0678p [L1]
L2 1 4 2.0678p [L2]
L3 5 4 2.0678p [L3]
L4 5 q0 2.0678p [L4]
L5 4 8 2.0678p [L5]
L6 8 q1 2.0678p [L6]

LP1 2 0 [LP1]
LP2 6 0 [LP2]
LP3 9 0 [LP3]
LB1 3 1 [LB1]
LB2 7 5 [LB2]
LB3 10 8 [LB3]

*Ports
P1 a 0
P2 q0 0
P3 q1 0
PB1 3 0
PB2 7 0
PB3 10 0
J1 1 2 250u
J2 5 6 250u
J3 8 9 250u
