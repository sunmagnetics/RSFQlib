* Circuit for InductEx extraction (excluding resistors)
* Author: L. Schindler
* Version: 2.1
* Last modification date: 24 April 2021
* Last modification by: L. Schindler

.control
	back-annotate LSmitll_SPLITT_v2p1_base.cir
.endc

*Inductors
L1 1 2 [L1]
L2 2 4 2.84p [L2]
L3 4 5 2.84p [L3]
L4 5 7 2.69p [L4]
L5 7 8 2.69p [L5]
L6 8 10 [L6]
L7 7 11 2.69p [L7]
L8 11 13 [L8]
LP1 3 0 [LP1]
LP2 6 0 [LP2]
LP3 9 0 [LP3]
LP4 12 0 [LP4]
LB1 14 4 [LB1]
LB2 18 8 [LB2]
LB3 111 11 [LB3]

*Ports
P1 1 0
P2 10 0
P3 13 0
PB1 14 0
PB2 18 0
PB3 111 0
J1 2 3 160u
J2 5 6 167u
J3 8 9 250u
J4 11 12 250u
