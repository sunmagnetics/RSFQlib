* Circuit for InductEx extraction (excluding resistors)
* Author: L. Schindler
* Version: 3.0
* Last modification date: 11 August 2022
* Last modification by: T. Hall

.control
	back-annotate THmitll_MERGET_v3p0_optimised.cir
.endc

*Inductors
L1 a 1 [L1]
L2 1 4 8.8600p  [L2]
L3 4 7 2.4587p  [L3]
L4 9 10 1.5077p [L4]
L5 b 11 [L5]
L6 11 14 8.8600p [L6]
L7 14 17 2.4587p [L7]
L8 19 10 1.5077p [L8]
L9 10 21 1.0056p [L9]
L10 21 24  [L10]

LB1 1 3   [LB1]
LB2 4 6   [LB2]
LB3 13 11 [LB3]
LB4 16 14 [LB4]
LB5 20 10 [LB5]
LB6 23 21 [LB6]

LP1 2 0  [LP1]
LP2 5 0  [LP2]
LP3 8 0  [LP3]
LP5 12 0 [LP5]
LP6 15 0 [LP6]
LP7 18 0 [LP7]
LP9 22 0 [LP9]

*Ports
P1 a 0
P2 b 0
P3 24 0

PB1 3 0
PB2 6 0
PB3 13 0
PB4 16 0
PB5 20 0
PB6 23 0

J1 1 2   160u
J2 4 5   110u
J3 7 8   261u
J4 7 9   156u
J5 11 12 160u
J6 14 15 110u
J7 17 18 261u
J8 17 19 156u
J9 21 22 250u
