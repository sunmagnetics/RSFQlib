* Circuit for InductEx extraction (excluding resistors)
* Author: L. Schindler
* Version: 2.1
* Last modification date: 12 January 2021
* Last modification by: L. Schindler

.control
	back-annotate LSmitll_JTL_v2p1_base.cir
.endc

* Inductors
L1 a 1 2.07p [L1]
L2 1 3 2.07p [L2]
L3 3 5 2.07p [L3]
L4 5 q 2.07p [L4]
LP1 2 0 [LP1]
LP2 6 0 [LP2]
LB1 3 4

* Ports
P1 a 0
P2 q 0
PB1 4 0
J1 1 2 250u
J2 5 6 250u
