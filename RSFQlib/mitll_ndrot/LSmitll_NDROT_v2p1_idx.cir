* Circuit for InductEx extraction (excluding resistors)
* Author: L. Schindler
* Version: 2.1
* Last modification date: 29 April 2021
* Last modification by: L. Schindler

.control
	back-annotate LSmitll_NDROT_v2p1_base.cir
.endc

* Inductors
L1 1 2 [L1]
L2 2 4 4.0481p [L2]
L3 4 6 3.6036p [L3]
L4 6 8 7.2183p [L4]
L5 8 11 3.0677p [L5]
L7 12 29 2.5596p [L7]
L8 16 17  [L8]
L9 17 19 4.0481p [L9]
L10 19 21 3.6036p [L10]
L11 21 23 4.3879p [L11]
L12 23 26 3.217p [L12]
L13 27 29 3.2439p [L13]
L14 33 34  [L14]
L15 34 36 4.3135p [L15]
L16 36 38 3.926p [L16]
L17 38 40 7.5833p [L17]
L18 40 42 1.2875p [L18]
L19 42 44 1.0678p [L19]
L21 30 31 0.37382p [L21]
L22 31 46 0.52995p [L22]
L23 46 47 0.95137p [L23]
L24 47 49 2.5089p [L24]
L25 49 51 1.2791p [L25]
L26 51 53 3.5427p [L26]
L27 53 56  [L27]
LP1 3 0 [LP1]
LP2 7 0 [LP2]
LP3 9 0 [LP3]
LP5 13 0 [LP5]
LP6 18 0 [LP6]
LP7 22 0 [LP7]
LP8 24 0 [LP8]
LP10 28 0 [LP10]
LP12 35 0 [LP12]
LP13 39 0 [LP13]
LP14 41 0 [LP14]
LP16 48 0 [LP16]
LP17 52 0 [LP17]
LP18 54 0 [LP18]
LB1 4 5 [LB1]
LB2 8 10 [LB2]
LB3 12 15 [LB3]
LB4 19 20 [LB4]
LB5 23 25 [LB5]
LB6 36 37 [LB6]
LB7 42 43 [LB7]
LB8 31 32 [LB8]
LB9 49 50 [LB9]
LB10 53 55 [LB10]

* Ports
P1 1 0
P2 16 0
P3 33 0
P4 56 0
PB1 5 0
PB2 10 0
PB3 15 0
PB4 20 0
PB5 25 0
PB6 37 0
PB7 43 0
PB8 32 0
PB9 50 0
PB10 55 0
J1 2 3 86u
J2 6 7 100u
J3 8 9 191u
J4 11 12 178u
J5 12 13 116u
J6 17 18 86u
J7 21 22 100u
J8 23 24 235u
J9 26 27 196u
J10 27 28 284u
J11 29 30 78u
J12 34 35 99u
J13 38 39 94u
J14 40 41 218u
J15 44 46 165u
J16 47 48 163u
J17 51 52 151u
J18 53 54 236u
.end
