* Circuit for InductEx extraction (excluding resistors)
* Author: L. Schindler
* Version: 2.1
* Last modification date: 3 March 2021
* Last modification by: L. Schindler
.control
	back-annotate LSmitll_SPLIT.cir
.endc

*Inductors
L1 111 1 2.068p [L1]
L2 1 4 3.64p [L2]
L3 4 7 1.27p [L3]
L4 7 8 1.30p [L4]
L5 8 112 2.068p [L5]
L6 7 11 1.30p [L6]
L7 11 113 2.068p [L7]

LP1 2 0 [LP1]
LP2 5 0 [LP2]
LP3 9 0 [LP3]
LP4 12 0 [LP4]
LB1 1 3 [LB1]
LB2 4 6 [LB2]
LB3 8 10 [LB3]
LB4 11 13 [LB4]

*Ports
P1 111 0
P2 112 0
P3 113 0
PB1 3 0
PB2 6 0
PB3 10 0
PB4 13 0
J1 1 2 250u
J2 4 5 300u
J3 8 9 250u
J4 11 12 250u
