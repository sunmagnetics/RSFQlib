* Circuit for InductEx extraction (excluding resistors)
* Author: L. Schindler
* Version: 2.1
* Last modification date: 27 April 2021
* Last modification by: L. Schindler

.control
	back-annotate LSmitll_DFFT_v2p1_base.cir
.endc

*Inductors
L1 1 2 [L1]
L2 2 4 3.28p [L2]
L3 4 6 3.28p [L3]
L4 6 8 4.06p [L4]
L5 9 12 7.51p [L5]
L6 14 15 [L6]
L7 15 17 3.04p [L7]
L8 17 19 3.04p  [L8]
L9 19 21 4.21p  [L9]
L10 12 22 4.02p [L10]
L11 22 24 2.15p [L11]
L12 24 26 2.15p [L12]
L13 26 28 [L13]
LP1 3 0  [LP1]
LP2 7 0   [LP2]
LP4 10 0   [LP4]
LP5 13 0   [LP5]
LP6 16 0   [LP6]
LP7 20 0   [LP7]
LP9 23 0  [LP9]
LP10 27 0  [LP10]
LB1 4 5   [LB1]
LB2 9 11  [LB2]
LB3 17 18   [LB3]
LB4 24 25   [LB4]

*Ports
P1 1 0
P2 14 0
P3 28 0
PB1 5 0
PB2 11 0
PB3 18 0
PB4 25 0
J1 2 3 162u
J2 6 7 189u
J3 8 9 172u
J4 9 10 232u
J5 12 13 212u
J6 15 16 160u
J7 19 20 198u
J8 21 12 171u
J9 22 23 212u
J10 26 27 250u
