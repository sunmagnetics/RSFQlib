* Generated by Xic from cell test_mitll_SFQDC
.tran 0.5p 1000p 0 0.25p UIC
.plot tran v(4) L1.x2#branch L13.x0#branch "v(1)/2O"
I0 0 4 pwl(0 0 20p 0 23p 600u 26p 0 70p 0 73p 600u 76p 0)
R0 1 0 2
X0 2 1 mitll_SFQDC
X1 4 3 mitll_DCSFQ
X2 3 2 MITLL_JTL
.subckt mitll_SFQDC P1 P2
B0 3 4 43 jjmit area=1.44
B1 5 24 44 jjmit area=2.33
B2 8 31 45 jjmit area=1.96
B3 9 33 46 jjmit area=1.96
B4 10 35 47 jjmit area=1.96
B5 6 7 48 jjmit area=1.32
B6 12 13 49 jjmit area=1.32
B7 14 15 50 jjmit area=1.44
B8 15 42 51 jjmit area=2.56
I0 0 16 pwl(0 0 5p 148u)
I1 0 19 pwl(0 0 5p 280u)
I2 0 20 pwl(0 0 5p 176u)
I3 0 21 pwl(0 0 5p 182u)
I4 0 22 pwl(0 0 5p 215u)
I5 0 23 pwl(0 0 5p 456u)
L0 16 4 0.078p
L1 17 4 1p
L2 4 5 0.494p
L3 18 0 1p
L4 24 0 0.837p
L5 5 6 4.839p
L6 19 25 0.169p
L7 20 26 0.192p
L8 21 27 0.239p
L9 3 28 0.853p
L10 22 12 2.145p
L11 23 29 0.013p
L12 30 7 1p
L13 P1 8 2.168p
L14 8 25 0.2p
L15 25 9 3.429p
L16 9 26 1.56p
L17 26 10 1.563p
L18 10 27 2.844p
L19 27 28 0.234p
L20 28 14 1.557p
L21 7 11 0.003p
L22 11 12 0.143p
L23 37 13 1p
L24 13 29 1.802p
L25 29 0 0.702p
L26 6 38 0.001p
L27 39 15 1p
L28 31 0 0.172p
L29 32 0 1p
L30 33 0 0.153p
L31 34 0 1p
L32 35 0 0.109p
L33 36 0 1p
L34 38 40 0.45p
L35 38 15 5.278p
L36 11 P2 7.21p
L37 41 0 1p
L38 42 0 0.855p
R0 3 17 7.847
R1 5 18 4.85
R2 6 30 8.561
R3 8 32 5.765
R4 9 34 5.765
R5 10 36 5.765
R6 12 37 8.561
R7 14 39 7.847
R8 40 0 0.3
R9 15 41 4.414
.ends mitll_SFQDC
.subckt mitll_DCSFQ IN OUT
B0 3 4 15 jjmit area=2.25
B1 5 10 16 jjmit area=2.25
B2 6 12 17 jjmit area=2.5
I0 0 7 pwl(0 0 5p 275u)
I1 0 8 pwl(0 0 5p 175u)
L0 7 4 0.2p
L1 8 6 0.2p
L2 IN 9 1p
L3 9 3 0.6p
L4 4 5 1.1p
L5 5 6 4.5p
L6 6 OUT 2p
L7 9 0 3.9p
L8 14 4 1p
L9 10 0 0.2p
L10 11 0 1p
L11 12 0 0.2p
L12 13 0 1p
R0 5 11 3.048846408
R1 6 13 2.743961767
R2 3 14 3.048846408
.ends mitll_DCSFQ
.subckt MITLL_JTL IN OUT
B0 3 7 11 jjmit area=2.5
B1 4 9 12 jjmit area=2.5
I0 0 5 pwl(0 0 5p 350u)
L0 5 6 1p
L1 IN 3 2p
L2 3 6 2p
L3 6 4 2p
L4 4 OUT 2p
L5 7 0 0.2p
L6 8 0 1p
L7 9 0 0.2p
L8 10 0 1p
R0 3 8 3.88
R1 4 10 3.88
.ends MITLL_JTL
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
.save @I0.X2[c]
.save @I0.X0[c]
.save @I4.X0[c]
.save @I5.X0[c]
.save @I1.X0[c]
.save @I2.X0[c]
.save @I3.X0[c]
.save @I0.X1[c]
.save @I1.X1[c]
.save @I0[c]
