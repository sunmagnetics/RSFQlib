* Generated by Xic from cell TEST_MITLL_JTLT
.tran 0.5p 100p 0 0.25p UIC
.plot tran L01rx1.x2#branch L1.x3#branch
I0 0 6 pwl(0 0 30p 0 33p 600u 36p 0 103p 0 106p 600u 109p 0)
R0 7 0 2
T1 2 0 3 0 Z0=5 Td=10p
T2 4 0 5 0 Z0=5 Td=10p
X0 6 1 MITLL_DCSFQ
X1 1 2 MITLL_PTLTX
X2 3 4 MITLL_JTLT
X3 5 7 MITLL_PTLRX
.subckt MITLL_PTLRX IN OUT
B0 3 8 14 jjmit area=1
B1 4 10 15 jjmit area=1
B2 5 12 16 jjmit area=1
I0 0 6 pwl(0 0 5p 155u)
L0 6 7 0.2p
L1 IN 3 0.2p
L2 3 7 4.3p
L3 7 4 4.6p
L4 4 5 5p
L5 5 OUT 2.3p
L6 8 0 0.34p
L7 9 0 0.5p
L8 10 0 0.06p
L9 11 0 1p
L10 12 0 0.03p
L11 13 0 1p
R0 3 9 6.859904418
R1 4 11 6.859904418
R2 5 13 6.859904418
.ends MITLL_PTLRX
.subckt MITLL_DCSFQ IN OUT
B0 3 4 15 jjmit area=2.25
B1 5 10 16 jjmit area=2.25
B2 6 12 17 jjmit area=2.5
I0 0 7 pwl(0 0 5p 275u)
I1 0 8 pwl(0 0 5p 175u)
L0 7 4 0.2p
L1 8 6 0.2p
L2 IN 9 1p
L3 9 3 0.6p
L4 4 5 1.1p
L5 5 6 4.5p
L6 6 OUT 2p
L7 9 0 3.9p
L8 14 4 1p
L9 10 0 0.2p
L10 11 0 1p
L11 12 0 0.2p
L12 13 0 1p
R0 5 11 3.048846408
R1 6 13 2.743961767
R2 3 14 3.048846408
.ends MITLL_DCSFQ
.subckt MITLL_JTLT IN OUT
.include MITLL_JTLT_models.inc
.param Scaling=1.0
.param B0=1
.param Ic0=0.0001
.param IcRs=100u*6.859904418
.param B0Rs=IcRs/Ic0*B0
.param B01rx1=0.6978965094340693*Scaling
.param B01tx1=1.7851040521840216*Scaling
.param B02rx1=0.4431557447885417*Scaling
.param B1=0.48805176033496367*Scaling
.param IB01rx1=8.645054846430082e-05*Scaling
.param IB01tx1=5.531224327588262e-05*Scaling
.param IB1=0.00012008182492244687*Scaling
.param L01rx1=3.3251593177777415e-13*(1/Scaling-(1-Scaling))
.param L01tx1=2.3256259129695253e-12*(1/Scaling-(1-Scaling))
.param L02rx1=2.4032152114216404e-12*(1/Scaling-(1-Scaling))
.param L03rx1=1.6772485370088992e-12*(1/Scaling-(1-Scaling))
.param L03tx1=2.3630198619224862e-13*(1/Scaling-(1-Scaling))
.param L1=2.5109096596962294e-12*(1/Scaling-(1-Scaling))
.param L2=8.665208165957606e-13*(1/Scaling-(1-Scaling))
.param LB1=1e-12/Scaling
.param LB2=1e-12/Scaling
.param LRB01rx1=1e-12/Scaling
.param LRB01tx1=1e-12/Scaling
.param LRB02rx1=1e-12/Scaling
.param RB01rx1=B0Rs/B01rx1
.param RB01tx1=B0Rs/B01tx1
.param RB02rx1=B0Rs/B02rx1
.param RB1=B0Rs/B1
.param RB2=B0Rs/B1
B01rx1 3 14 24 jmitll area=B01rx1
B01tx1 7 22 28 jmitll area=B01tx1
B02rx1 4 16 25 jmitll area=B02rx1
B1 5 18 26 jmitll area=B1
B2 6 20 27 jmitll area=B1
IB01rx1 0 8 pwl(0 0 5p IB01rx1)
IB01tx1 0 10 pwl(0 0 5p IB01tx1)
IB1 0 9 pwl(0 0 5p IB1)
L01rx1 IN 3 L01rx1
L01tx1 6 7 L01tx1
L02rx1 3 11 L02rx1
L03rx1 11 4 L03rx1
L03tx1 7 13 L03tx1
L1 4 5 L1
L2 5 12 L2
L3 12 6 L2
LB1 19 0 LB1
LB2 21 0 LB2
LP01rx1 14 0 2e-13
LP01tx1 22 0 2e-13
LP02rx1 16 0 2e-13
LP1 18 0 2e-13
LP2 20 0 2e-13
LPR01rx1 8 11 2e-13
LPR01tx1 10 7 2e-13
LRB01rx1 15 0 LRB01rx1
LRB01tx1 23 0 LRB01tx1
LRB02rx1 17 0 LRB02rx1
LRP1 9 12 2e-13
R0 13 OUT 1.36
RB01rx1 3 15 RB01rx1
RB01tx1 7 23 RB01tx1
RB02rx1 4 17 RB02rx1
RB1 5 19 RB1
RB2 6 21 RB2
.ends MITLL_JTLT
.subckt MITLL_PTLTX IN OUT
B0 3 8 12 jjmit area=2
B1 4 10 13 jjmit area=1.62
I0 0 5 pwl(0 0 5p 230u)
I1 0 6 pwl(0 0 5p 82u)
L0 5 3 0.2p
L1 6 4 1.3p
L2 IN 3 2.5p
L3 3 4 3.3p
L4 4 7 0.35p
L5 8 0 0.05p
L6 9 0 1p
L7 10 0 0.12p
L8 11 0 1p
R0 7 OUT 1.36
R1 3 9 4.85
R2 4 11 6.3
.ends MITLL_PTLTX
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
.save @IB01rx1.X2[c]
.save @IB1.X2[c]
.save @IB01tx1.X2[c]
.save @I0.X1[c]
.save @I1.X1[c]
.save @I0.X0[c]
.save @I1.X0[c]
.save @I0.X3[c]
.save @I0[c]
