* Generated by Xic from cell TEST_MITLL_NOTT
.tran 0.25p 1000p 0 0.25p UIC
.plot tran @I0[c] @I1[c] "v(3)/2O"
I0 0 10 pulse(0 600u 1p 2p 2p 1p 50p)
I1 0 11 pwl(0 0 30p 0 33p 600u 36p 0 100p 0 103p 600u 106p 0 110p 0 113p 600u
+ 116p 0)
R0 3 0 2
T1 9 0 7 0 Z0=5 Td=10p
T2 5 0 6 0 Z0=5 Td=10p
T3 1 0 2 0 Z0=5 Td=10p
X0 6 7 1 MITLL_NOTT
X1 2 3 MITLL_PTLRX
X2 10 4 MITLL_DCSFQ
X3 4 5 MITLL_PTLTX
X4 11 8 MITLL_DCSFQ
X5 8 9 MITLL_PTLTX
.subckt MITLL_PTLRX IN OUT
B0 3 8 14 jjmit area=1
B1 4 10 15 jjmit area=1
B2 5 12 16 jjmit area=1
I0 0 6 pwl(0 0 5p 155u)
L0 6 7 0.2p
L1 IN 3 0.2p
L2 3 7 4.3p
L3 7 4 4.6p
L4 4 5 5p
L5 5 OUT 2.3p
L6 8 0 0.34p
L7 9 0 0.5p
L8 10 0 0.06p
L9 11 0 1p
L10 12 0 0.03p
L11 13 0 1p
R0 3 9 6.859904418
R1 4 11 6.859904418
R2 5 13 6.859904418
.ends MITLL_PTLRX
.subckt MITLL_DCSFQ IN OUT
B0 3 4 15 jjmit area=2.25
B1 5 10 16 jjmit area=2.25
B2 6 12 17 jjmit area=2.5
I0 0 7 pwl(0 0 5p 275u)
I1 0 8 pwl(0 0 5p 175u)
L0 7 4 0.2p
L1 8 6 0.2p
L2 IN 9 1p
L3 9 3 0.6p
L4 4 5 1.1p
L5 5 6 4.5p
L6 6 OUT 2p
L7 9 0 3.9p
L8 14 4 1p
L9 10 0 0.2p
L10 11 0 1p
L11 12 0 0.2p
L12 13 0 1p
R0 5 11 3.048846408
R1 6 13 2.743961767
R2 3 14 3.048846408
.ends MITLL_DCSFQ
.subckt MITLL_NOTT IN CLK OUT
.include MITLL_NOTT_models.inc
.param Scaling=1.0
.param B0=1
.param Ic0=0.0001
.param IcRs=100u*6.859904418
.param B0Rs=IcRs/Ic0*B0
.param Rsheet=2
.param Lsheet=1.13e-12
.param B01=1.34878778*Scaling
.param B01rx1=1.261343*Scaling
.param B01rx2=1.24756*Scaling
.param B01tx1=2.85095985*Scaling
.param B02=0.771808*Scaling
.param B03=1.22266656*Scaling
.param B05=1.222101*Scaling
.param B06=1.04322587*Scaling
.param B07=2.21390932*Scaling
.param B09=1.40994860*Scaling
.param B10=1.72270993*Scaling
.param B11=1.41930907*Scaling
.param IB01rx1=0.000146094*Scaling
.param IB01rx2=0.000181215*Scaling
.param IB01tx1=1.87178366e-04*Scaling
.param IB02=9.69782457e-05*Scaling
.param IB03=9.52213294e-05*Scaling
.param IB04=1.01564048e-04*Scaling
.param IB06=1.08369267e-04*Scaling
.param L01=2.28471245e-12*(1/Scaling-(1-Scaling))
.param L01rx1=1.85704981e-12*(1.5/Scaling-(1.5-Scaling))
.param L01rx2=2.14574120e-12*(1.5/Scaling-(1.5-Scaling))
.param L01tx1=4.51952153e-12*(1.5/Scaling-(1.5-Scaling))
.param L02rx1=4.47184231e-12*(1.5/Scaling-(1.5-Scaling))
.param L02rx2=2.54674768e-12*(1.5/Scaling-(1.5-Scaling))
.param L02tx1=3.47235380e-12*(1.5/Scaling-(1.5-Scaling))
.param L03=6.59615220e-12*(2/Scaling-(2-Scaling))
.param L04=4.24131804e-13*(1.5/Scaling-(1.5-Scaling))
.param L06=3.28595668e-12*(1.5/Scaling-(1.5-Scaling))
.param L07=4.99854579e-13*(1.5/Scaling-(1.5-Scaling))
.param L08=8.69457755e-13*(1.5/Scaling-(1.5-Scaling))
.param L09=2.84165222e-13*(1.5/Scaling-(1.5-Scaling))
.param L10=7.11635824e-12*(1.5/Scaling-(1.5-Scaling))
.param L12=2.65317712e-12*(0.9/Scaling-(0.9-Scaling))
.param L13=2.15661026e-12*(1.5/Scaling-(1.5-Scaling))
.param L16=2.61168134e-12*(1.5/Scaling-(1.5-Scaling))
.param L17=9.91803133e-13*(1.5/Scaling-(1.5-Scaling))
.param L18=2.58423937e-13*(1.5/Scaling-(1.5-Scaling))
.param L19=3.16811349e-12*(1.5/Scaling-(1.5-Scaling))
.param L20=1.16758799e-12*(1.5/Scaling-(1.5-Scaling))
.param L21=7.46110928e-13*(1.5/Scaling-(1.5-Scaling))
.param LRB01=(RB01/Rsheet)*Lsheet
.param LRB01rx1=(RB01rx1/Rsheet)*Lsheet
.param LRB01rx2=(RB01rx2/Rsheet)*Lsheet
.param LRB01tx1=(RB01tx1/Rsheet)*Lsheet
.param LRB02=(RB02/Rsheet)*Lsheet
.param LRB03=(RB03/Rsheet)*Lsheet
.param LRB05=(RB05/Rsheet)*Lsheet
.param LRB06=(RB06/Rsheet)*Lsheet
.param LRB07=(RB07/Rsheet)*Lsheet
.param LRB09=(RB09/Rsheet)*Lsheet
.param LRB10=(RB10/Rsheet)*Lsheet
.param LRB11=(RB11/Rsheet)*Lsheet
.param RB01=B0Rs/B01
.param RB01rx1=B0Rs/B01rx1
.param RB01rx2=B0Rs/B01rx2
.param RB01tx1=B0Rs/B01tx1
.param RB02=B0Rs/B02
.param RB03=B0Rs/B03
.param RB05=B0Rs/B05
.param RB06=B0Rs/B06
.param RB07=B0Rs/B07
.param RB09=B0Rs/B09
.param RB10=B0Rs/B10
.param RB11=B0Rs/B11
B01 4 5 58 jmitll area=B01
B01rx1 17 49 64 jmitll area=B01rx1
B01rx2 12 37 60 jmitll area=B01rx2
B01tx1 8 29 57 jmitll area=B01tx1
B02 14 9 59 jmitll area=B02
B03 14 15 63 jmitll area=B03
B05 10 41 62 jmitll area=B05
B06 6 25 55 jmitll area=B06
B07 13 39 61 jmitll area=B07
B09 7 27 56 jmitll area=B09
B10 19 53 66 jmitll area=B10
B11 18 51 65 jmitll area=B11
IB01rx1 0 44 pwl(0 0 5p IB01rx1)
IB01rx2 0 31 pwl(0 0 5p IB01rx2)
IB01tx1 0 21 pwl(0 0 5p IB01tx1)
IB02 0 33 pwl(0 0 5p IB02)
IB03 0 32 pwl(0 0 5p IB03)
IB04 0 45 pwl(0 0 5p IB04)
IB06 0 20 pwl(0 0 5p IB06)
L01 10 4 L01
L01rx1 CLK 17 L01rx1
L01rx2 IN 12 L01rx2
L01tx1 7 8 L01tx1
L02rx1 17 46 L02rx1
L02rx2 12 34 L02rx2
L02tx1 8 24 L02tx1
L03 10 36 L03
L04 36 14 L04
L06 35 10 L06
L07 5 9 L07
L08 15 16 L08
L09 5 6 L09
L10 6 22 L10
L12 47 16 L12
L13 34 13 L13
L16 46 18 L16
L17 13 35 L17
L18 16 19 L18
L19 19 48 L19
L20 18 47 L20
L21 22 7 L21
LP01rx1 49 0 0.34p
LP01rx2 37 0 0.34p
LP01tx1 29 0 0.05p
LP05 41 0 0.567p
LP06 25 0 0.27p
LP07 39 0 0.328p
LP09 27 0 0.12p
LP10 53 0 0.239p
LP11 51 0 0.109p
LPR01rx1 46 44 0.2p
LPR01rx2 31 34 0.2p
LPR01tx1 21 8 0.2p
LPR02 33 36 0.023p
LPR03 32 35 0.208p
LPR04 47 45 0.216p
LPR06 20 22 0.13p
LRB01 23 5 LRB01
LRB01rx1 50 0 LRB01rx1
LRB01rx2 38 0 LRB01rx2
LRB01tx1 30 0 LRB01tx1
LRB02 9 11 LRB02
LRB03 43 15 LRB03
LRB05 42 0 LRB05
LRB06 26 0 LRB06
LRB07 40 0 LRB07
LRB09 28 0 LRB09
LRB10 54 0 LRB10
LRB11 52 0 LRB11
RB01 4 23 RB01
RB01rx1 17 50 RB01rx1
RB01rx2 12 38 RB01rx2
RB01tx1 8 30 RB01tx1
RB02 11 14 RB02
RB03 14 43 RB03
RB05 10 42 RB05
RB06 6 26 RB06
RB07 13 40 RB07
RB09 7 28 RB09
RB10 19 54 RB10
RB11 18 52 RB11
RD 48 0 3.54
RINStx1 24 OUT 1.36
.ends MITLL_NOTT
.subckt MITLL_PTLTX IN OUT
B0 3 8 12 jjmit area=2
B1 4 10 13 jjmit area=1.62
I0 0 5 pwl(0 0 5p 230u)
I1 0 6 pwl(0 0 5p 82u)
L0 5 3 0.2p
L1 6 4 1.3p
L2 IN 3 2.5p
L3 3 4 3.3p
L4 4 7 0.35p
L5 8 0 0.05p
L6 9 0 1p
L7 10 0 0.12p
L8 11 0 1p
R0 7 OUT 1.36
R1 3 9 4.85
R2 4 11 6.3
.ends MITLL_PTLTX
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
.save @IB01rx1.X0[c]
.save @IB06.X0[c]
.save @IB01tx1.X0[c]
.save @IB01rx2.X0[c]
.save @IB03.X0[c]
.save @IB02.X0[c]
.save @IB04.X0[c]
.save @I0.X3[c]
.save @I1.X3[c]
.save @I0.X5[c]
.save @I1.X5[c]
.save @I0.X2[c]
.save @I1.X2[c]
.save @I0.X4[c]
.save @I1.X4[c]
.save @I0.X1[c]
.save @I0[c]
.save @I1[c]
