* Generated by Xic from cell TEST_MITLL_SPLITT
.tran 0.5p 400p 0 0.25p UIC
.plot tran L01rx1.x0#branch "(v(11.x0)-v(3))/1.36O" "(v(24.x0)-v(6))/1.36O"
I0 0 10 pwl(0 0 100p 0 103p 600u 106p 0)
R0 2 0 2
R1 8 0 2
T1 4 0 5 0 Z0=5 Td=10p
T2 3 0 1 0 Z0=5 Td=10p
T3 6 0 7 0 Z0=5 Td=10p
X0 5 3 6 MITLL_SPLITT
X1 1 2 MITLL_PTLRX
X2 10 9 MITLL_DCSFQ
X3 9 4 MITLL_PTLTX
X4 7 8 MITLL_PTLRX
.subckt MITLL_PTLRX IN OUT
B0 3 8 14 jjmit area=1
B1 4 10 15 jjmit area=1
B2 5 12 16 jjmit area=1
I0 0 6 pwl(0 0 5p 155u)
L0 6 7 0.2p
L1 IN 3 0.2p
L2 3 7 4.3p
L3 7 4 4.6p
L4 4 5 5p
L5 5 OUT 2.3p
L6 8 0 0.34p
L7 9 0 0.5p
L8 10 0 0.06p
L9 11 0 1p
L10 12 0 0.03p
L11 13 0 1p
R0 3 9 6.859904418
R1 4 11 6.859904418
R2 5 13 6.859904418
.ends MITLL_PTLRX
.subckt MITLL_DCSFQ IN OUT
B0 3 4 15 jjmit area=2.25
B1 5 10 16 jjmit area=2.25
B2 6 12 17 jjmit area=2.5
I0 0 7 pwl(0 0 5p 275u)
I1 0 8 pwl(0 0 5p 175u)
L0 7 4 0.2p
L1 8 6 0.2p
L2 IN 9 1p
L3 9 3 0.6p
L4 4 5 1.1p
L5 5 6 4.5p
L6 6 OUT 2p
L7 9 0 3.9p
L8 14 4 1p
L9 10 0 0.2p
L10 11 0 1p
L11 12 0 0.2p
L12 13 0 1p
R0 5 11 3.048846408
R1 6 13 2.743961767
R2 3 14 3.048846408
.ends MITLL_DCSFQ
.subckt MITLL_SPLITT IN OUT_1 OUT_2
.include MITLL_SPLITT_models.inc
.param Scaling=1.0
.param B0=1
.param Ic0=0.0001
.param IcRs=100u*6.859904418
.param B0Rs=IcRs/Ic0*B0
.param Rsheet=2
.param Lsheet=1.13e-12
.param B01rx1=1.0070354868519553*Scaling
.param B01tx1=1.6993237776942893*Scaling
.param B1=1.6959682291689977*Scaling
.param B2=1.209509885398233*Scaling
.param IB01rx1=0.00013494761741656282*Scaling
.param IB01tx1=7.626696604705507e-05*Scaling
.param IB1=0.00035968318587602715*Scaling
.param L01rx1=2.6757035519114777e-13*(1/Scaling-(1-Scaling))
.param L02tx1=2.2253212527851025e-12*(1/Scaling-(1-Scaling))
.param L1=1.5258529970572481e-12*(1/Scaling-(1-Scaling))
.param L2=2.9153847294043574e-12*(1/Scaling-(1-Scaling))
.param L3=4.813688043861165e-13*(1/Scaling-(1-Scaling))
.param L4=1.2716425006912427e-12*(1/Scaling-(1-Scaling))
.param L5=1.2572241510058017e-12*(1/Scaling-(1-Scaling))
.param LRB01rx1=(RB01rx1/Rsheet)*Lsheet
.param LRB01tx1=(RB01tx1/Rsheet)*Lsheet
.param LRB1=(RB1/Rsheet)*Lsheet
.param LRB2=(RB2/Rsheet)*Lsheet
.param RB01rx1=B0Rs/B01rx1
.param RB01tx1=B0Rs/B01tx1
.param RB1=B0Rs/B1
.param RB2=B0Rs/B2
B01rx1 6 20 32 jmitll area=B01rx1
B01tx1 5 16 31 jmitll area=B01tx1
B01tx2 9 28 35 jmitll area=B01tx1
B1 7 22 33 jmitll area=B1
B2 4 14 30 jmitll area=B2
B3 8 25 34 jmitll area=B2
IB01rx1 0 12 pwl(0 0 5p IB01rx1)
IB01tx1 0 10 pwl(0 0 5p IB01tx1)
IB01tx2 0 27 pwl(0 0 5p IB01tx1)
IB1 0 13 pwl(0 0 5p IB1)
L01rx1 IN 6 L01rx1
L02tx1 5 11 L02tx1
L02tx2 9 24 L02tx1
L1 6 7 L1
L2 7 18 L2
L3 18 19 L3
L4 4 19 L4
L5 4 5 L5
L6 19 8 L4
L7 8 9 L5
LP01rx1 20 0 0.34p
LP01tx1 16 0 0.05p
LP01tx2 28 0 0.05p
LP1 22 0 0.2p
LP2 14 0 0.2p
LP3 25 0 0.2p
LPR01rx1 12 6 0.2p
LPR01tx1 10 5 0.2p
LPR01tx2 9 27 0.2p
LPRIB1 13 18 0.2p
LRB01rx1 21 0 LRB01rx1
LRB01tx1 17 0 LRB01tx1
LRB01tx2 29 0 LRB01tx1
LRB1 23 0 LRB1
LRB2 15 0 LRB2
LRB3 26 0 LRB2
RB01rx1 6 21 RB01rx1
RB01tx1 5 17 RB01tx1
RB01tx2 9 29 RB01tx1
RB1 7 23 RB1
RB2 4 15 RB2
RB3 8 26 RB2
RINStx1 11 OUT_1 1.36
RINStx2 24 OUT_2 1.36
.ends MITLL_SPLITT
.subckt MITLL_PTLTX IN OUT
B0 3 8 12 jjmit area=2
B1 4 10 13 jjmit area=1.62
I0 0 5 pwl(0 0 5p 230u)
I1 0 6 pwl(0 0 5p 82u)
L0 5 3 0.2p
L1 6 4 1.3p
L2 IN 3 2.5p
L3 3 4 3.3p
L4 4 7 0.35p
L5 8 0 0.05p
L6 9 0 1p
L7 10 0 0.12p
L8 11 0 1p
R0 7 OUT 1.36
R1 3 9 4.85
R2 4 11 6.3
.ends MITLL_PTLTX
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* YBCO
.save @I0.X3[c]
.save @I1.X3[c]
.save @IB01tx1.X0[c]
.save @IB01rx1.X0[c]
.save @IB1.X0[c]
.save @IB01tx2.X0[c]
.save @I0.X2[c]
.save @I1.X2[c]
.save @I0.X1[c]
.save @I0.X4[c]
.save @I0[c]
