* Generated by Xic from cell TEST_MITLL_MERGET
.tran 0.5p 600p 0 0.25p UIC

.param Scaling=1.0
.param B0=1
.param Ic0=0.0001
.param IcRs=100u*6.859904418
.param B0Rs=IcRs/Ic0*B0

.param B01rx1=0.406096932932737*Scaling
.param B01tx1=1.6170270947092646*Scaling
.param B1=1.3297290261410297*Scaling
.param B2=0.9441504843661195*Scaling
.param B5=0.4699573551784042*Scaling
.param IB01rx1=5.78131351728159e-05*Scaling
.param IB01tx1=9.865761633800178e-05*Scaling
.param IB1=0.00021301934603711183*Scaling
.param L01rx1=1.022895099801e-13*(1/Scaling-(1-Scaling))
.param L02rx1=3.652077177182586e-13*(1/Scaling-(1-Scaling))
.param L02tx1=7.968312323853429e-13*(1/Scaling-(1-Scaling))
.param L1=1.9844995155650543e-12*(1/Scaling-(1-Scaling))
.param L2=4.2509601789948834e-13*(1/Scaling-(1-Scaling))
.param L6=3.2497900816335613e-12*(1/Scaling-(1-Scaling))
.param L7=3.113676024551185e-12*(1/Scaling-(1-Scaling))
.param LRB01rx1=5e-13/Scaling
.param LRB01rx2=5e-13/Scaling
.param LRB01tx1=1e-12/Scaling
.param LRB1=1e-12/Scaling
.param LRB2=1e-12/Scaling
.param LRB3=1e-12/Scaling
.param LRB4=1e-12/Scaling
.param LRB5=1e-12/Scaling
.param RB01rx1=B0Rs/B01rx1
.param RB01rx2=B0Rs/B01rx1
.param RB01tx1=B0Rs/B01tx1
.param RB1=B0Rs/B1
.param RB2=B0Rs/B2
.param RB3=B0Rs/B1
.param RB4=B0Rs/B2
.param RB5=B0Rs/B5

I0 0 1 pulse(0 600u 1p 2p 2p 1p 50p)
I1 0 9 pwl(0 0 50p 0 53p 600u 56p 0 200p 0 203p 600u 206p 0)
R0 7 0 2
T1 3 0 4 0 Z0=5 Td=10p
T2 11 0 8 0 Z0=5 Td=10p
T3 5 0 6 0 Z0=5 Td=10p
X0 1 2 MITLL_DCSFQ
X1 2 3 MITLL_PTLTX
X2 4 8 5 MITLL_MERGET
X3 6 7 MITLL_PTLRX
X4 9 10 MITLL_DCSFQ
X5 10 11 MITLL_PTLTX

.subckt MITLL_MERGET IN_1 IN_2 OUT
B01rx1 6 16 35 jmitll area=B01rx1
B01rx2 12 30 40 jmitll area=B01rx1
B01tx1 9 26 38 jmitll area=B01tx1
B1 4 18 36 jmitll area=B1
B2 4 5 34 jmitll area=B2
B3 10 32 41 jmitll area=B1
B4 10 11 39 jmitll area=B2
B5 8 24 37 jmitll area=B5
IB01rx1 0 13 pwl(0 0 5p IB01rx1)
IB01rx2 0 22 pwl(0 0 5p IB01rx1)
IB01tx1 0 21 pwl(0 0 5p IB01tx1)
IB1 0 20 pwl(0 0 5p IB1)
L01rx1 IN_1 6 L01rx1
L01rx2 IN_2 12 L01rx1
L02rx1 6 14 L02rx1
L02rx2 12 28 L02rx1
L02tx1 9 23 L02tx1
L1 14 4 L1
L2 5 7 L2
L3 28 10 L1
L4 11 7 L2
L6 7 8 L6
L7 8 9 L7
LP01rx1 16 0 0.34p
LP01rx2 30 0 0.34p
LP01tx1 26 0 0.05p
LP1 18 0 0.2p
LP3 32 0 0.2p
LP5 24 0 0.2p
LPR01rx1 13 14 0.2p
LPR01rx2 22 28 0.2p
LPR01tx1 21 9 0.2p
LPR1 20 7 0.2p
LRB01rx1 17 0 LRB01rx1
LRB01rx2 31 0 LRB01rx2
LRB01tx1 27 0 LRB01tx1
LRB1 19 0 LRB1
LRB2 15 5 LRB2
LRB3 33 0 LRB3
LRB4 29 11 LRB4
LRB5 25 0 LRB5
RB01rx1 6 17 RB01rx1
RB01rx2 12 31 RB01rx2
RB01tx1 9 27 RB01tx1
RB1 4 19 RB1
RB2 4 15 RB2
RB3 10 33 RB3
RB4 10 29 RB4
RB5 8 25 RB5
RINStx1 23 OUT 1.36
.ends MITLL_MERGET

.subckt MITLL_PTLRX IN OUT
B0 3 8 14 jjmit area=1
B1 4 10 15 jjmit area=1
B2 5 12 16 jjmit area=1
I0 0 6 pwl(0 0 5p 155u)
L0 6 7 0.2p
L1 IN 3 0.2p
L2 3 7 4.3p
L3 7 4 4.6p
L4 4 5 5p
L5 5 OUT 2.3p
L6 8 0 0.34p
L7 9 0 0.5p
L8 10 0 0.06p
L9 11 0 1p
L10 12 0 0.03p
L11 13 0 1p
R0 3 9 6.859904418
R1 4 11 6.859904418
R2 5 13 6.859904418
.ends MITLL_PTLRX
.subckt MITLL_DCSFQ IN OUT
B0 3 4 15 jjmit area=2.25
B1 5 10 16 jjmit area=2.25
B2 6 12 17 jjmit area=2.5
I0 0 7 pwl(0 0 5p 275u)
I1 0 8 pwl(0 0 5p 175u)
L0 7 4 0.2p
L1 8 6 0.2p
L2 IN 9 1p
L3 9 3 0.6p
L4 4 5 1.1p
L5 5 6 4.5p
L6 6 OUT 2p
L7 9 0 3.9p
L8 14 4 1p
L9 10 0 0.2p
L10 11 0 1p
L11 12 0 0.2p
L12 13 0 1p
R0 5 11 3.048846408
R1 6 13 2.743961767
R2 3 14 3.048846408
.ends MITLL_DCSFQ
.subckt MITLL_PTLTX IN OUT
B0 3 8 12 jjmit area=2
B1 4 10 13 jjmit area=1.62
I0 0 5 pwl(0 0 5p 230u)
I1 0 6 pwl(0 0 5p 82u)
L0 5 3 0.2p
L1 6 4 1.3p
L2 IN 3 2.5p
L3 3 4 3.3p
L4 4 7 0.35p
L5 8 0 0.05p
L6 9 0 1p
L7 10 0 0.12p
L8 11 0 1p
R0 7 OUT 1.36
R1 3 9 4.85
R2 4 11 6.3
.ends MITLL_PTLTX
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

.model jmitll jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* Nb 4500 A/cm2
.save @I0.X0[c]
.save @I1.X0[c]
.save @I0.X4[c]
.save @I1.X4[c]
.save @IB01rx1.X2[c]
.save @IB1.X2[c]
.save @IB01tx1.X2[c]
.save @IB01rx2.X2[c]
.save @I0.X3[c]
.save @I0.X1[c]
.save @I1.X1[c]
.save @I0.X5[c]
.save @I1.X5[c]
.save @I0[c]
.save @I1[c]
