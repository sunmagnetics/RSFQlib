* Generated by Xic from cell MITLL_AND2T
* Author: L. Schindler
* Version: 1.1.31
* Last modification date: 26 October 2018
* Last modification by: L. Schindler

.tran 0.5p 600p 0 0.25p UIC
.include MITLL_AND2T_models.inc
.param Scaling=1.0
.param B0=1.0
.param Ic0=0.0001
.param IcRs=100u*6.859904418
.param B0Rs=IcRs/Ic0*B0
.param Rsheet=2
.param Lsheet=1.13e-12
.param B01=1.3190*Scaling
.param B01rx2=0.8806*Scaling
.param B01rx3=0.9014*Scaling
.param B01tx1=2.2663*Scaling
.param B03=1.13403*Scaling
.param B05=1.5270*Scaling
.param B07=1.2572*Scaling
.param B08=1.1670*Scaling
.param B09=2.0355*Scaling
.param B10=1.7593*Scaling
.param B14=1.5018*Scaling
.param IB01=0.0001132685*Scaling
.param IB01rx2=0.0001314468*Scaling
.param IB01rx3=0.0001275400*Scaling
.param IB01tx1=0.0002136646*Scaling
.param IB03=6.26758e-05*Scaling
.param IB07=0.0001792992*Scaling
.param L01=2.5797e-12*(1/Scaling-(1-Scaling))
.param L01rx2=1.5369e-12*(1/Scaling-(1-Scaling))
.param L01rx3=1.7746e-12*(1/Scaling-(1-Scaling))
.param L01tx1=1.5369e-12*(1/Scaling-(1-Scaling))
.param L02tx1=2.7428e-12*(1/Scaling-(1-Scaling))
.param L03=1.9325e-12*(1/Scaling-(1-Scaling))
.param L05=1.1464e-12*(1/Scaling-(1-Scaling))
.param L07=1.9932e-12*(1/Scaling-(1-Scaling))
.param L08=3.9e-14*(1/Scaling-(1-Scaling))
.param L09=2.9248e-12*(1/Scaling-(1-Scaling))
.param L13=2.2304e-12*(1/Scaling-(1-Scaling))
.param L15=6.1049e-12*(1/Scaling-(1-Scaling))
.param L17=1.9428e-12*(1/Scaling-(1-Scaling))
.param L19=2.0373e-13*(1/Scaling-(1-Scaling))
.param L20=3.9901e-13*(1/Scaling-(1-Scaling))
.param L21=1.2909e-13*(1/Scaling-(1-Scaling))
.param L23=1e-14*(1/Scaling-(1-Scaling))
.param LRB01=(RB01/Rsheet)*Lsheet
.param LRB01rx2=(RB01rx2/Rsheet)*Lsheet
.param LRB01rx3=(RB01rx3/Rsheet)*Lsheet
.param LRB01tx1=(RB01tx1/Rsheet)*Lsheet
.param LRB03=(RB03/Rsheet)*Lsheet
.param LRB05=(RB05/Rsheet)*Lsheet
.param LRB07=(RB07/Rsheet)*Lsheet
.param LRB08=(RB08/Rsheet)*Lsheet
.param LRB09=(RB09/Rsheet)*Lsheet
.param LRB10=(RB10/Rsheet)*Lsheet
.param LRB14=(RB14/Rsheet)*Lsheet
.param RB01=B0Rs/B01
.param RB01rx2=B0Rs/B01rx2
.param RB01rx3=B0Rs/B01rx3
.param RB01tx1=B0Rs/B01tx1
.param RB03=B0Rs/B03
.param RB05=B0Rs/B05
.param RB07=B0Rs/B07
.param RB08=B0Rs/B08
.param RB09=B0Rs/B09
.param RB10=B0Rs/B10
.param RB14=B0Rs/B14
B01 7 32 68 jmitll area=B01
B01rx1 5 28 66 jmitll area=B01rx2
B01rx2 20 60 79 jmitll area=B01rx2
B01rx3 13 43 71 jmitll area=B01rx3
B01tx1 18 53 76 jmitll area=B01tx1
B02 22 64 81 jmitll area=B01
B03 8 10 69 jmitll area=B03
B04 23 19 77 jmitll area=B03
B05 9 11 70 jmitll area=B05
B06 24 11 78 jmitll area=B05
B07 16 49 74 jmitll area=B07
B08 15 47 73 jmitll area=B08
B09 17 51 75 jmitll area=B09
B10 6 30 67 jmitll area=B10
B11 21 62 80 jmitll area=B10
B14 14 45 72 jmitll area=B14
IB01 0 26 pwl(0 0 5p IB01)
IB01rx1 0 25 pwl(0 0 5p IB01rx2)
IB01rx2 0 55 pwl(0 0 5p IB01rx2)
IB01rx3 0 36 pwl(0 0 5p IB01rx3)
IB01tx1 0 39 pwl(0 0 5p IB01tx1)
IB02 0 56 pwl(0 0 5p IB01)
IB03 0 38 pwl(0 0 5p IB03)
IB07 0 37 pwl(0 0 5p IB07)
L01 8 9 L01
L01rx1 IN_1 5 L01rx2
L01rx2 IN_2 20 L01rx2
L01rx3 IN_CLK 13 L01rx3
L01tx1 17 18 L01tx1
L02 23 24 L01
L02tx1 18 42 L02tx1
L03 6 27 L03
L04 21 59 L03
L05 10 12 L05
L06 12 19 L05
L07 40 15 L07
L08 16 41 L08
L09 41 17 L09
L13 5 6 L13
L14 20 21 L13
L15 27 7 L15
L16 59 22 L15
L17 13 14 L17
L19 14 40 L19
L20 11 16 L20
L21 7 8 L21
L22 22 23 L21
L23 15 12 L23
LP01 32 0 2.55e-13
LP01rx1 28 0 3.4e-13
LP01rx2 60 0 3.4e-13
LP01rx3 43 0 3.4e-13
LP01tx1 53 0 5e-14
LP02 64 0 2.55e-13
LP07 49 0 2.99e-13
LP08 47 0 2.11e-13
LP09 51 0 1.74e-13
LP10 30 0 2.21e-13
LP11 62 0 2.21e-13
LP14 45 0 1.87e-13
LPR01rx1 25 5 2e-13
LPR01rx2 55 20 2e-13
LPR01rx3 36 13 2e-13
LPR01tx1 39 18 2e-13
LPR1 26 27 1.3e-14
LPR2 56 59 1.3e-14
LPR3 38 41 1.901e-12
LPR4 37 40 8.5e-13
LRB01 33 0 LRB01
LRB01rx1 29 0 LRB01rx2
LRB01rx2 61 0 LRB01rx2
LRB01rx3 44 0 LRB01rx3
LRB01tx1 54 0 LRB01tx1
LRB02 65 0 LRB01
LRB03 34 10 LRB03
LRB04 19 57 LRB03
LRB05 35 11 LRB05
LRB06 11 58 LRB05
LRB07 50 0 LRB07
LRB08 48 0 LRB08
LRB09 52 0 LRB09
LRB10 31 0 LRB10
LRB11 63 0 LRB10
LRB14 46 0 LRB14
RB01 7 33 RB01
RB01rx1 5 29 RB01rx2
RB01rx2 20 61 RB01rx2
RB01rx3 13 44 RB01rx3
RB01tx1 18 54 RB01tx1
RB02 22 65 RB01
RB03 8 34 RB03
RB04 57 23 RB03
RB05 9 35 RB05
RB06 58 24 RB05
RB07 16 50 RB07
RB08 15 48 RB08
RB09 17 52 RB09
RB10 6 31 RB10
RB11 21 63 RB10
RB14 14 46 RB14
RINStx1 42 OUT 1.36
