* Generated by Xic from cell mitll_SFQDC
* Author: L. Schindler
* Version: 1.1
* Last modification date: 26 October 2018
* Last modification by: L. Schindler

.tran 0.5p 100p 0 0.25p UIC
B0 3 4 43 jjmit area=1.44
B1 5 24 44 jjmit area=2.33
B2 8 31 45 jjmit area=1.96
B3 9 33 46 jjmit area=1.96
B4 10 35 47 jjmit area=1.96
B5 6 7 48 jjmit area=1.32
B6 12 13 49 jjmit area=1.32
B7 14 15 50 jjmit area=1.44
B8 15 42 51 jjmit area=2.56
I0 0 16 pwl(0 0 5p 148u)
I1 0 19 pwl(0 0 5p 280u)
I2 0 20 pwl(0 0 5p 176u)
I3 0 21 pwl(0 0 5p 182u)
I4 0 22 pwl(0 0 5p 215u)
I5 0 23 pwl(0 0 5p 456u)
L0 16 4 0.078p
L1 17 4 1p
L2 4 5 0.494p
L3 18 0 1p
L4 24 0 0.837p
L5 5 6 4.839p
L6 19 25 0.169p
L7 20 26 0.192p
L8 21 27 0.239p
L9 3 28 0.853p
L10 22 12 2.145p
L11 23 29 0.013p
L12 30 7 1p
L13 P1 8 2.168p
L14 8 25 0.2p
L15 25 9 3.429p
L16 9 26 1.56p
L17 26 10 1.563p
L18 10 27 2.844p
L19 27 28 0.234p
L20 28 14 1.557p
L21 7 11 0.003p
L22 11 12 0.143p
L23 37 13 1p
L24 13 29 1.802p
L25 29 0 0.702p
L26 6 38 0.001p
L27 39 15 1p
L28 31 0 0.172p
L29 32 0 1p
L30 33 0 0.153p
L31 34 0 1p
L32 35 0 0.109p
L33 36 0 1p
L34 38 40 0.45p
L35 38 15 5.278p
L36 11 P2 7.21p
L37 41 0 1p
L38 42 0 0.855p
R0 3 17 7.847
R1 5 18 4.85
R2 6 30 8.561
R3 8 32 5.765
R4 9 34 5.765
R5 10 36 5.765
R6 12 37 8.561
R7 14 39 7.847
R8 40 0 0.3
R9 15 41 4.414
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)
