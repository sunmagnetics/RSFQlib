* Generated by Xic from cell MITLL_NDROT
.tran 0.5p 1000p 0 0.25p UIC

.param Scaling=1.0
.param B0=1
.param Ic0=0.0001
.param IcRs=100u*6.859904418
.param B0Rs=IcRs/Ic0*B0

.param B01=2.1788399302058328*Scaling
.param B01rx1=0.8596715235590455*Scaling
.param B01rx3=0.9892029833667483*Scaling
.param B01tx1=2.3613474994575965*Scaling
.param B02=1.6498418078316253*Scaling
.param B02rx1=1.0002064168816702*Scaling
.param B02rx3=0.9426302107353123*Scaling
.param B03=2.346444294038123*Scaling
.param B04=1.959719668899844*Scaling
.param B05=2.8367568100690996*Scaling
.param B06=1.9079333820062683*Scaling
.param B07=1.774936463415763*Scaling
.param B08=1.161873602860789*Scaling
.param B09=0.7782136162931658*Scaling
.param B10=1.6312905658688257*Scaling
.param B11=1.5078865547595564*Scaling
.param IB01=0.00022385147240104272*Scaling
.param IB01rx1=0.00013414240085083285*Scaling
.param IB01rx3=0.00013179770453636912*Scaling
.param IB01tx1=0.00019550907771059744*Scaling
.param IB02=0.00015219252954919415*Scaling
.param IB03=0.0001980857825625136*Scaling
.param IB04=9.851658491710679e-05*Scaling
.param IB05=9.472815335373098e-05*Scaling
.param IB06=6.36746817353646e-05*Scaling
.param L01=7.583253898110444e-12*(1/Scaling-(1-Scaling))
.param L01rx1=1.9122271431208015e-12*(1/Scaling-(1-Scaling))
.param L01rx3=1.7868861603532337e-12*(1/Scaling-(1-Scaling))
.param L01tx1=3.542674238775056e-12*(1/Scaling-(1-Scaling))
.param L02=1.3381364079735137e-12*(1/Scaling-(1-Scaling))
.param L02rx1=4.048126383444853e-12*(1/Scaling-(1-Scaling))
.param L02rx3=4.313533638451465e-12*(1/Scaling-(1-Scaling))
.param L02tx1=3.5269876551915765e-12*(1/Scaling-(1-Scaling))
.param L03=4.387868619800262e-12*(1/Scaling-(1-Scaling))
.param L03rx1=3.6035853045412023e-12*(1/Scaling-(1-Scaling))
.param L03rx3=3.9259512228634774e-12*(1/Scaling-(1-Scaling))
.param L04=3.216968283885101e-12*(1/Scaling-(1-Scaling))
.param L05=7.2182844653910156e-12*(1/Scaling-(1-Scaling))
.param L06=3.0676981292950732e-12*(1/Scaling-(1-Scaling))
.param L07=2.5596303355721674e-12*(1/Scaling-(1-Scaling))
.param L08=3.243894306062451e-12*(1/Scaling-(1-Scaling))
.param L09=3.7381664270667463e-13*(1/Scaling-(1-Scaling))
.param L10=5.299363605457756e-13*(1/Scaling-(1-Scaling))
.param L11=2.5087689323982963e-12*(1/Scaling-(1-Scaling))
.param L13=9.513656670568208e-13*(1/Scaling-(1-Scaling))
.param L14=4.752763562613125e-14*(1/Scaling-(1-Scaling))
.param L15=1.2874701900487265e-12*(1/Scaling-(1-Scaling))
.param L16=1.0677668196342924e-12*(1/Scaling-(1-Scaling))
.param L17=1.2791051325983638e-12*(1/Scaling-(1-Scaling))
.param LRB01=1e-12/Scaling
.param LRB01rx1=5e-13/Scaling
.param LRB01rx3=5e-13/Scaling
.param LRB01rx3=5e-13/Scaling
.param LRB01tx1=1e-12/Scaling
.param LRB02=1e-12/Scaling
.param LRB02rx1=1e-12/Scaling
.param LRB02rx2=1e-12/Scaling
.param LRB02rx3=1e-12/Scaling
.param LRB03=1e-12/Scaling
.param LRB04=1e-12/Scaling
.param LRB05=1e-12/Scaling
.param LRB06=1e-12/Scaling
.param LRB07=1e-12/Scaling
.param LRB08=1e-12/Scaling
.param LRB09=1e-12/Scaling
.param LRB10=1e-12/Scaling
.param LRB11=1e-12/Scaling
.param RB01=B0Rs/B01
.param RB01rx1=B0Rs/B01rx1
.param RB01rx2=B0Rs/B01rx1
.param RB01rx3=B0Rs/B01rx3
.param RB01tx1=B0Rs/B01tx1
.param RB02=B0Rs/B02
.param RB02rx1=B0Rs/B02rx1
.param RB02rx2=B0Rs/B02rx1
.param RB02rx3=B0Rs/B02rx3
.param RB03=B0Rs/B03
.param RB04=B0Rs/B04
.param RB05=B0Rs/B05
.param RB06=B0Rs/B06
.param RB07=B0Rs/B07
.param RB08=B0Rs/B08
.param RB09=B0Rs/B09
.param RB10=B0Rs/B10
.param RB11=B0Rs/B11

B01 22 66 89 jmitll area=B01
B01rx1 7 32 76 jmitll area=B01rx1
B01rx2 13 44 81 jmitll area=B01rx1
B01rx3 20 62 87 jmitll area=B01rx3
B01tx1 25 73 92 jmitll area=B01tx1
B02 18 19 86 jmitll area=B02
B02rx1 8 34 77 jmitll area=B02rx1
B02rx2 14 46 82 jmitll area=B02rx1
B02rx3 21 64 88 jmitll area=B02rx3
B03 15 48 83 jmitll area=B03
B04 11 12 80 jmitll area=B04
B05 12 50 84 jmitll area=B05
B06 9 36 78 jmitll area=B06
B07 5 6 75 jmitll area=B07
B08 6 38 79 jmitll area=B08
B09 10 16 85 jmitll area=B09
B10 23 69 90 jmitll area=B10
B11 24 71 91 jmitll area=B11
IB01 0 68 pwl(0 0 5p IB01)
IB01rx1 0 26 pwl(0 0 5p IB01rx1)
IB01rx2 0 40 pwl(0 0 5p IB01rx1)
IB01rx3 0 53 pwl(0 0 5p IB01rx3)
IB01tx1 0 55 pwl(0 0 5p IB01tx1)
IB02 0 41 pwl(0 0 5p IB02)
IB03 0 27 pwl(0 0 5p IB03)
IB04 0 30 pwl(0 0 5p IB04)
IB05 0 56 pwl(0 0 5p IB05)
IB06 0 17 pwl(0 0 5p IB06)
L01 21 22 L01
L01rx1 IN_SET 7 L01rx1
L01rx2 IN_RESET 13 L01rx1
L01rx3 IN_CLK 20 L01rx3
L01tx1 24 25 L01tx1
L02 19 58 L02
L02rx1 7 28 L02rx1
L02rx2 13 42 L02rx1
L02rx3 20 57 L02rx3
L02tx1 25 61 L02tx1
L03 14 15 L03
L03rx1 28 8 L03rx1
L03rx2 42 14 L03rx1
L03rx3 57 21 L03rx3
L04 15 11 L04
L05 8 9 L05
L06 9 5 L06
L07 31 10 L07
L08 12 10 L08
L09 16 54 L09
L10 54 58 L10
L11 23 17 L11
L13 58 23 L13
L14 6 31 L14
L15 22 60 L15
L16 60 18 L16
L17 17 24 L17
LP01 66 0 1.56e-13
LP01rx1 32 0 3.4e-13
LP01rx2 44 0 3.4e-13
LP01rx3 62 0 3.4e-13
LP01tx1 73 0 5e-14
LP02rx1 34 0 6e-14
LP02rx2 46 0 6e-14
LP02rx3 64 0 6e-14
LP03 48 0 1.35e-13
LP05 50 0 1.4599999999999998e-13
LP06 36 0 1.3300000000000001e-13
LP08 38 0 2.16e-13
LP10 69 0 1.4599999999999998e-13
LP11 71 0 1.35e-13
LPR01 60 68 1.8199999999999998e-13
LPR01rx1 26 28 2e-13
LPR01rx2 40 42 2e-13
LPR01rx3 53 57 2e-13
LPR01tx1 55 25 2e-13
LPR02 41 15 1.53e-13
LPR03 27 9 1.85e-13
LPR04 30 31 2.5059999999999996e-12
LPR05 54 56 3.4e-14
LRB01 67 0 LRB01
LRB01rx1 33 0 LRB01rx1
LRB01rx2 45 0 LRB01rx1
LRB01rx3 63 0 LRB01rx3
LRB01tx1 74 0 LRB01tx1
LRB02 59 19 LRB02
LRB02rx1 35 0 LRB02rx1
LRB02rx2 47 0 LRB02rx2
LRB02rx3 65 0 LRB02rx3
LRB03 49 0 LRB03
LRB04 43 12 LRB04
LRB05 51 0 LRB05
LRB06 37 0 LRB06
LRB07 29 6 LRB07
LRB08 39 0 LRB08
LRB09 52 16 LRB09
LRB10 70 0 LRB10
LRB11 72 0 LRB11
RB01 22 67 RB01
RB01rx1 7 33 RB01rx1
RB01rx2 13 45 RB01rx2
RB01rx3 20 63 RB01rx3
RB01tx1 25 74 RB01tx1
RB02 18 59 RB02
RB02rx1 8 35 RB02rx1
RB02rx2 14 47 RB02rx2
RB02rx3 21 65 RB02rx3
RB03 15 49 RB03
RB04 11 43 RB04
RB05 12 51 RB05
RB06 9 37 RB06
RB07 5 29 RB07
RB08 6 39 RB08
RB09 10 52 RB09
RB10 23 70 RB10
RB11 24 72 RB11
RINStx1 61 OUT 1.36
.model jjmit jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

.model jmitll jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)

* Nb 4500 A/cm2
.save @IB01rx3[c]
.save @IB01rx1[c]
.save @IB01rx2[c]
.save @IB01tx1[c]
.save @IB02[c]
.save @IB03[c]
.save @IB04[c]
.save @IB06[c]
.save @IB05[c]
.save @IB01[c]
